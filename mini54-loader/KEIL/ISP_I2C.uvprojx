# Keil uVision project ISP_I2C.uvprojx, settings and files
target ISP_I2C (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Mini54ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.26
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: ISP_I2C
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CMSIS\Include;..\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_Mini51Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../: startup_Mini51Series.s
    ../CMSIS/: system_Mini51Series.c
  group User
    ../: main.c FMC_USER.c ISP_USER.c targetdev.c i2c_transfer.c
software components: CMSIS:CORE 5.4.0
