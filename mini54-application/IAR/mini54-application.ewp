# IAR project mini54-application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M051DN series Nuvoton M051DN series (M052DN,M054DN,M058DN,M0516DN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\Library\CMSIS\Include; ..\Library\Device\Nuvoton\M051Series\Include; ..\Library\StdDriver\inc; ..\hal\inc; ..\hal\src\anx_ohio; ..\board; ..\core; ..\core\regist; ..\core\lib\inc; ..\function\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mini54-application.bin
  ILINK.IlinkOutputFile: sm1.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Mini51DE series Nuvoton Mini51DE series (Mini51DE,Mini52DE,Mini54DE)
  ICCARM.CCDefines: LONGLAKE_DEBUG
  ICCARM.CCIncludePath2: ..\Library\CMSIS\Include; ..\Library\Device\Nuvoton\Mini51Series\Include; ..\Library\StdDriver\inc; ..\board; ..\core; ..\core\lib\inc; ..\function\inc
  ICCARM.CCOptLevel: 2
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: ..\config\generic_cortex.icf
  group board
    ../board/: board.c
  group CMSIS
    ../Library/Device/Nuvoton/Mini51Series/Source/IAR/: startup_Mini51Series.s
    ../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
  group core
    ../core/: core.c
  group function
    ../function/src/: ir.c pm.c update.c wol.c
  group Library
    ../Library/StdDriver/src/: clk.c fmc.c gpio.c i2c.c pwm.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
