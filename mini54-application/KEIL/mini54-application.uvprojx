# Keil uVision project mini54-application.uvprojx, settings and files
target application (6160000::V6.16::ARMCLANG)
  device: Mini54ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.26
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: mini54-application +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __IDE_KEIL__
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\Mini51Series\Include;..\Library\StdDriver\inc;..\board;..\core\lib\inc;..\core;..\function\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  scatter file: ..\config\mini54-application.sct
  link misc: --entry Reset_Handler
  group Library
    ../Library/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c
    ../Library/Device/Nuvoton/Mini51Series/Source/: system_Mini51Series.c
    ../Library/Device/Nuvoton/Mini51Series/Source/ARM/: startup_Mini51Series.s
  group board
    ../board/: board.c
  group core
    ../core/: core.c
  group function
    ../function/src/: pm.c update.c wol.c led.c power_control.c adc_key.c
  group main
    ../: main.c
